<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.6'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gain_offset_dB</value></param>
<param><key>value</key><value>18.86</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>file_name</value></param>
<param><key>value</key><value>file_name_string if record_check_box==True else "/dev/null"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>filter_taps</value></param>
<param><key>value</key><value>firdes.low_pass(1.0,2.5,0.1,0.02,firdes.WIN_HAMMING)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>usrp_DDC_freq</value></param>
<param><key>value</key><value>np.round(usrp_ask_freq/usrp_clk_rate* 2**32)/2**32 * usrp_clk_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>usrp_ask_freq</value></param>
<param><key>value</key><value>band_freq+offset_tune_freq</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>lo_freq</value></param>
<param><key>value</key><value>usrp_DDC_freq + coarse_tuner_freq + fine_tuner_freq - offset_tune_freq</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>250000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>usrp_clk_rate</value></param>
<param><key>value</key><value>200E6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>offset_tune_freq</value></param>
<param><key>value</key><value>-10E3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>RX_power_offset_dB</value></param>
<param><key>value</key><value>-35.2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>file_name_string</value></param>
<param><key>value</key><value>str(int(time.mktime(time.gmtime())))+"UTC_"+'{:.6f}'.format(lo_freq)+"Hz"+"_"+str(int(samp_rate/100))+"sps"+".raw"</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>Setup USRP with offset tuning to avoid DDC DC spike</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1</value></param>
<param><key>note</key><value>Calculate true DDC frequency</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_4</value></param>
<param><key>note</key><value>Create a filename string consisting of UTC UNIX time, LO frequency, and sample rate</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_3</value></param>
<param><key>note</key><value>Setup a coarse and fine tuners for a local oscillator</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_2</value></param>
<param><key>note</key><value>Sharper filtering since USRP roll-off is too shallow</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_6</value></param>
<param><key>note</key><value>Same filter taps used for all decimators </value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_5</value></param>
<param><key>note</key><value>Two stages of decimation to tune a 2500 Hz channel</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>blocks_probe_signal_x_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>10</value></param>
<param><key>taps</key><value>filter_taps</value></param>
<param><key>center_freq</key><value>lo_freq - usrp_DDC_freq</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>file_name</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_7</value></param>
<param><key>note</key><value>Write to file when box is checked</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>record_check_box</value></param>
<param><key>label</key><value>"Record"</value></param>
<param><key>type</key><value>bool</value></param>
<param><key>value</key><value>False</value></param>
<param><key>true</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>6,5,1,1</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate/100</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
<param><key>freq</key><value>600</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0_0_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>10</value></param>
<param><key>taps</key><value>filter_taps</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>gain</key><value>10**(gain_offset_dB/20)</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>cutoff_freq</key><value>100E3</value></param>
<param><key>width</key><value>20E3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import time</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0</value></param>
<param><key>n</key><value>10</value></param>
<param><key>k</key><value>RX_power_offset_dB</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>fine_tuner_freq</value></param>
<param><key>label</key><value>"Fine Tuner (Hz)"</value></param>
<param><key>value</key><value>0</value></param>
<param><key>start</key><value>-500</value></param>
<param><key>stop</key><value>500</value></param>
<param><key>step</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>3,5,1,5</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0_0</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_1_0</value></param>
</block>
<block>
<key>hilbert_fc</key>
<param><key>id</key><value>hilbert_fc_0</value></param>
<param><key>num_taps</key><value>65</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>hilbert_fc</key>
<param><key>id</key><value>hilbert_fc_0_0</value></param>
<param><key>num_taps</key><value>65</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>type</key><value>fff</value></param>
<param><key>interp</key><value>48000</value></param>
<param><key>decim</key><value>2500</value></param>
<param><key>taps</key><value></value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>analog_agc3_xx</key>
<param><key>id</key><value>analog_agc3_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>attack_rate</key><value>1e-1</value></param>
<param><key>decay_rate</key><value>1e-4</value></param>
<param><key>reference</key><value>volume/100</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>max_gain</key><value>2**16</value></param>
<param><key>iir_update_decim</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>band_freq</value></param>
<param><key>label</key><value>"Band"</value></param>
<param><key>type</key><value>real</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>value</key><value>7.055E6</value></param>
<param><key>options</key><value>[1.84E6, 3.598E6, 7.055E6, 2.5E6, 5.0E6, 10.0E6]</value></param>
<param><key>labels</key><value>["160m", "80m", "40m", "2.5 MHz", "5 MHz", "10 MHz"]</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>gui_hint</key><value>4,5,1,1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>coarse_tuner_freq</value></param>
<param><key>label</key><value>"Coarse Tuner (Hz)"</value></param>
<param><key>value</key><value>0</value></param>
<param><key>start</key><value>-samp_rate/2</value></param>
<param><key>stop</key><value>samp_rate/2</value></param>
<param><key>step</key><value>100</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>min_len</key><value>50</value></param>
<param><key>gui_hint</key><value>3,0,1,5</value></param>
</block>
<block>
<key>blocks_integrate_xx</key>
<param><key>id</key><value>blocks_integrate_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>decim</key><value>500</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>variable_function_probe_0</value></param>
<param><key>value</key><value>0</value></param>
<param><key>block_id</key><value>blocks_probe_signal_x_0</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>poll_rate</key><value>5</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>filename_label</value></param>
<param><key>label</key><value>"File Name"</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>file_name</value></param>
<param><key>gui_hint</key><value>6,6,1,3</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>volume</value></param>
<param><key>label</key><value>Volume</value></param>
<param><key>value</key><value>5.0</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>10.0</value></param>
<param><key>step</key><value>1.0</value></param>
<param><key>widget</key><value>knob</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>min_len</key><value>100</value></param>
<param><key>gui_hint</key><value>5,6,1,1</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_0</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate/100</value></param>
<param><key>cutoff_freq</key><value>0.9*cw_filter_bw</value></param>
<param><key>width</key><value>0.1*cw_filter_bw</value></param>
<param><key>win</key><value>firdes.WIN_BLACKMAN</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>str(samp_rate/100) + " Hz Channel Spectrum"</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>lo_freq</value></param>
<param><key>bw</key><value>samp_rate/100</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>ymin</key><value>-120</value></param>
<param><key>ymax</key><value>-70</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>gui_hint</key><value>0,5,3,5</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>label2</key><value></value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>lo_freq_label</value></param>
<param><key>label</key><value>"LO Freq (Hz)"</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>'{:.6f}'.format(lo_freq)</value></param>
<param><key>gui_hint</key><value>4,6,1,1</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>"Band Spectrum"</value></param>
<param><key>fftsize</key><value>4096</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>usrp_DDC_freq</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>average</key><value>0.2</value></param>
<param><key>ymin</key><value>-110</value></param>
<param><key>ymax</key><value>-60</value></param>
<param><key>gui_hint</key><value>0,0,3,5</value></param>
<param><key>showports</key><value>True</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>"Band Waterfall"</value></param>
<param><key>fftsize</key><value>4096</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>usrp_DDC_freq</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>int_min</key><value>-100</value></param>
<param><key>int_max</key><value>-70</value></param>
<param><key>gui_hint</key><value>4,0,3,5</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>color1</key><value>5</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_10</value></param>
<param><key>note</key><value>Calculate filtered channel power and offset</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>rx_power_label</value></param>
<param><key>label</key><value>"RX Power (dBm)"</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>'{:.1f}'.format(variable_function_probe_0)</value></param>
<param><key>gui_hint</key><value>4,7,1,1</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_8</value></param>
<param><key>note</key><value>Narrow band filter but preserve 2.5 ksps for BFO audio</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_9</value></param>
<param><key>note</key><value>BFO moves baseband to audio</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>cw_filter_bw</value></param>
<param><key>label</key><value>"CW Filter BW"</value></param>
<param><key>type</key><value>real</value></param>
<param><key>num_opts</key><value>3</value></param>
<param><key>value</key><value>1000</value></param>
<param><key>option0</key><value>100</value></param>
<param><key>label0</key><value>"100 Hz"</value></param>
<param><key>option1</key><value>500</value></param>
<param><key>label1</key><value>"500 Hz"</value></param>
<param><key>option2</key><value>1000</value></param>
<param><key>label2</key><value>"1 kHz"</value></param>
<param><key>gui_hint</key><value>5,5,1,1</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_args</key><value>"addr=192.168.40.2"</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>sd_spec0</key><value>"B:A"</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>usrp_ask_freq</value></param>
<param><key>gain0</key><value>6</value></param>
<param><key>ant0</key><value></value></param>
</block>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>fir_filter_xxx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0_0_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0_0_0</source_block_id><sink_block_id>low_pass_filter_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>blocks_integrate_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_integrate_xx_0</source_block_id><sink_block_id>blocks_nlog10_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0</source_block_id><sink_block_id>blocks_probe_signal_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>analog_agc3_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_agc3_xx_0</source_block_id><sink_block_id>blocks_complex_to_float_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0_0</source_block_id><sink_block_id>blocks_null_sink_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_null_sink_1_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_1_0</source_block_id><sink_block_id>hilbert_fc_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hilbert_fc_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_1_0</source_block_id><sink_block_id>hilbert_fc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hilbert_fc_0_0</source_block_id><sink_block_id>blocks_complex_to_float_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
